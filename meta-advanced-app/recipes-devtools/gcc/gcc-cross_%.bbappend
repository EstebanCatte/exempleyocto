PV = "13.4.0"

SRC_URI = "https://ftp.gnu.org/gnu/gcc/gcc-${PV}/gcc-${PV}.tar.xz"
SRC_URI[sha256sum] = "7449a5b3f548d1d81084b6dd81d830b8064a33edb2c2f217865263d049402120"
